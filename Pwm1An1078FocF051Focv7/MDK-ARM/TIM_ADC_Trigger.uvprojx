# Keil uVision project TIM_ADC_Trigger.uvprojx, settings and files
target TIM_ADC_Trigger (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TIM_ADC_Trigger +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\TIM_ADC_Trigger;..\EWARM;..\HARDWARE;.\TIM_ADC_Trigger;..\SYSTEM;..\STM32F0xx_StdPeriph_Driver\inc;..\STM32F0xx_StdPeriph_Driver\src;..\TASKING;..\USER;..\SensorlessFOC;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../USER/: main.c Contrl.c System.c
  group MDK-ARM
    ./: startup_stm32f0xx.s
  group CORTEX_M0 LIB
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_cec.c stm32f0xx_misc.c stm32f0xx_pwr.c
  group HARDWARE
    ../HARDWARE/: ADC_CFG.c TMER_CFG.c UART_CFG.c
  group SYSTEM
    ../SYSTEM/: stm32f0xx_it.c system_stm32f0xx.c stm32f0xx.h system_stm32f0xx.h
  group FOC
    ../USER/: FOC.c
    ../SensorlessFOC/: PMSM.c smcpos.c MeasCurr.c cordic.c
